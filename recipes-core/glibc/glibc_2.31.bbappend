ASSESSOR_NAME       = "Naoto Yamaguchi"
CODING_RULE         = "https://sourceware.org/glibc/wiki/Style_and_Conventions"
CONTRIBUTION_RULE   = "https://sourceware.org/glibc/wiki/Contribution%20checklist"
RELEASE_RULE        = "https://sourceware.org/glibc/wiki/Glibc%20Timeline"
CHANGE_LOG          = "https://sourceware.org/glibc/wiki/Glibc%20Timeline"
BUGTRACKER          = "https://sourceware.org/bugzilla/describecomponents.cgi?product=glibc"
TEST_SUITE          = "https://sourceware.org/glibc/wiki/Testing/Testsuite"
USED_IN             = "TBD"
ACTIVE_CONTRIBUTORS = "https://sourceware.org/glibc/wiki/MAINTAINERS"
OIN_LIST            = "746@Table10"

inherit assesment
