ASSESSOR_NAME       = "Naoto Yamaguchi"
CODING_RULE         = "https://git.busybox.net/busybox/tree/docs/style-guide.txt?h=1_31_stable"
CONTRIBUTION_RULE   = "https://busybox.net/developer.html"
RELEASE_RULE        = "https://busybox.net/"
CHANGE_LOG          = "https://busybox.net/"
BUG_TRACKING        = "https://bugs.busybox.net/describecomponents.cgi?product=Busybox"
TEST_SUITE          = "https://git.busybox.net/busybox/tree/testsuite?h=1_31_stable"
USED_IN             = "TBD"
ACTIVE_CONTRIBUTORS = "https://git.busybox.net/busybox/tree/AUTHORS?h=1_31_stable"
OIN_LIST            = "258@Table10"

inherit assesment
