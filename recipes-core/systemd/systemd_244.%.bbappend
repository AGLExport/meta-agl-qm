ASSESSOR_NAME       = "Naoto Yamaguchi"
CODING_RULE         = "https://systemd.io/CODING_STYLE/"
CONTRIBUTION_RULE   = "https://systemd.io/CONTRIBUTING/"
RELEASE_RULE        = "https://github.com/systemd/systemd/tags"
CHANGE_LOG          = "https://github.com/systemd/systemd/commits/main"
BUG_TRACKING        = "https://github.com/systemd/systemd/issues"
TEST_SUITE          = "https://github.com/systemd/systemd/tree/main/test"
USED_IN             = "TBD"
ACTIVE_CONTRIBUTORS = "https://github.com/systemd/systemd/graphs/contributors"
OIN_LIST            = "2917@Table10"

inherit assesment
