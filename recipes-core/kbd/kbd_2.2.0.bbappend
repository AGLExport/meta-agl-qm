ASSESSOR_NAME       = "Naoto Yamaguchi"
CODING_RULE         = "https://git.kernel.org/pub/scm/linux/kernel/git/legion/kbd.git/tree/docs/process/howto-contribute.md"
CONTRIBUTION_RULE   = "https://git.kernel.org/pub/scm/linux/kernel/git/legion/kbd.git/tree/docs/process/howto-contribute.md"
RELEASE_RULE        = "https://git.kernel.org/pub/scm/linux/kernel/git/legion/kbd.git/refs/tags"
CHANGE_LOG          = "https://git.kernel.org/pub/scm/linux/kernel/git/legion/kbd.git/log/"
BUG_TRACKING        = "https://lists.altlinux.org/pipermail/kbd/"
TEST_SUITE          = "https://git.kernel.org/pub/scm/linux/kernel/git/legion/kbd.git/tree/tests"
USED_IN             = "TBD"
ACTIVE_CONTRIBUTORS = "https://github.com/legionus/kbd/graphs/contributors"
OIN_LIST            = "1167@Table10"

inherit assesment
